# Keil uVision project t2.uvprojx, settings and files
target EXTI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: t2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c led.c beep.c key.c exti.c systime.c timer.c pwm.c usart.c rtc.c adc.c getdht.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
